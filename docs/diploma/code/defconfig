## docs/diploma/code/defconfig
```kconfig
CONFIG_ZRAM=y
CONFIG_ZRAM_DEF_COMP_ZSTD=y
CONFIG_ZRAM_DEF_COMP="zstd"
CONFIG_ZRAM_ENTROPY=y
CONFIG_ZRAM_ENTROPY_THRESHOLD=100000
```
